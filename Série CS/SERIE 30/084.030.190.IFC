Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: 084.030.190.IFC
Time: 2021-02-05T15:49:59
Written by: SwIFC
Made in: SolidWorks 2018

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 084.030.190
In: Default Storey
Material: X8CrNiS 18-9 (AISI 303)
